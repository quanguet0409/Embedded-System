# Keil uVision project Final project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Final project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: gpio.c gpio.h lcd.c lcd.h leds.c leds.h mma8451.c mma8451.h step_counter.c step_counter.h switches.c switches.h systick.c systick.h timer.c timer.h main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
